# Keil uVision project fadingLED.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  pack: Keil.LM4F_DFP.1.0.0
  cpu: IRAM(0x10000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: fadingLED
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PART_LM4F120H5QR
  memory RVCT4: ROM 0x0 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: fadingLED.c fadingLED.h Retarget.c
    ./drivers/: driverlib-cm4f.lib lcd.c gpio.c interrupt.c sysctl.c timer.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
