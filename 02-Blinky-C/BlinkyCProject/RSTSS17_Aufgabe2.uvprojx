# Keil uVision project RSTSS17_Aufgabe2.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LM4F120H5QR Texas Instruments
  pack: Keil.LM4F_DFP.1.0.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x10000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RSTSS15_Aufgabe2_loesung
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: blinky.c lcd.c Retarget.c Startup.s
