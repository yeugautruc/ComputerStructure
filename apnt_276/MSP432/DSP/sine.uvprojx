# Keil uVision project sine.uvprojx, settings and files
target XSD110 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.2.2.0
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sine
  c flags: Optim=1 wLevel=2
  c define: ARM_MATH_CM4  __FPU_PRESENT
  c include: .\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source Group 1
    ./src/: DirtyFilter.c low_pass_filter.c sine_generator.c
  group ReadMe
    ./: Abstract.txt
target ULINK2 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.2.2.0
  cpu: as above
  output: sine
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: ARM_MATH_CM4  __FPU_PRESENT
  c include: .\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
target ULINKpro (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.2.2.0
  cpu: as above
  output: sine
  c flags: Optim=1 wLevel=2
  c define: ARM_MATH_CM4  __FPU_PRESENT
  c include: .\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
target J-Link (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.2.2.0
  cpu: as above
  output: sine
  c flags: Optim=1 wLevel=2
  c define: ARM_MATH_CM4  __FPU_PRESENT
  c include: .\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6, CMSIS:RTOS:Keil RTX 4.81.0, Compiler:I/O:STDOUT 1.1.0, Device:Startup 2.2.0
